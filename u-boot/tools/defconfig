## u-boot/tools/defconfig
```kconfig
CONFIG_SYS_TEXT_BASE=0x0
CONFIG_FIT=y
CONFIG_FIT_SIGNATURE=y
CONFIG_FIT_ENABLE_RSASSA_PSS_SUPPORT=y
CONFIG_FIT_VERBOSE=y
```
